# Keil uVision project stm32f4xx_project.uvprojx, settings and files
target stm32f4xx_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4xx_project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\CMSIS\Include;.\USER\USART;.\USER\KEY;.\USER\LED;.\USER\NVIC;.\USER\ADC;.\USER\SYSTICK;.\USER\TIME;.\USER;.\USER\METHOD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ./USER/: main.c
    ./USER/NVIC/: nvic.c
    ./USER/USART/: usart.c
    ./USER/KEY/: key.c
    ./USER/LED/: led.c
    ./USER/ADC/: adc.c
    ./USER/SYSTICK/: systick.c
    ./USER/TIME/: time6.c time_gen.c time.c
    ./USER/METHOD/: method.c
