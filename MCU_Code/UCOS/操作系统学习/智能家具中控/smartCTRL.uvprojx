# Keil uVision project smartCTRL.uvprojx, settings and files
target SMARTCTRL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smartCTRL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\USER;.\USER\BSP;.\USER\DMA;.\USER\LCD;.\USER\SPI;.\USER\SYSTICK;.\USER\REALYS;.\USER\NRF;.\USER\USART;.\USER\KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c app.c includes.h app.h stm32f10x_it.c
  group BSP
    ./USER/BSP/: bsp.c bsp.h
    ./USER/LCD/: lcd.c lcd_init.c
    ./USER/SPI/: spi.c
    ./USER/DMA/: dma.c
    ./USER/SYSTICK/: systick.c
    ./USER/REALYS/: bsp_relays.c
    ./USER/NRF/: nrf24l01.c
    ./USER/USART/: bsp_usart.c
    ./USER/KEY/: bsp_key.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
