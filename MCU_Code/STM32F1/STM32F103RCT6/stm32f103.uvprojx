# Keil uVision project stm32f103.uvprojx, settings and files
target stm32f103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\USER\LED;.\USER\KEY;.\USER\RCCCLK;.\USER\EXTI;.\USER;.\USER\SYSTICK;.\USER\USART;.\USER\DMA;.\USER\I2C;.\USER\SPI;.\USER\SPI\flash;.\USER\FATFS;.\USER\ADC;.\USER\TIME\BASICTIM;.\USER\TIME\ADVTIM;.\USER\TIME\GENTIM;.\USER\NEC;.\USER\WDG;.\USER\SPI\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ./USER/LED/: led.c
    ./USER/KEY/: key.c
    ./USER/I2C/: i2c.c
    ./USER/SPI/flash/: flash_spi.c
    ./USER/ADC/: adc.c adc_dma.c
    ./USER/NEC/: remote.c
    ./USER/SPI/OLED/: oled.c
  group SYSTEM
    ./USER/SYSTICK/: systick.c
    ./USER/RCCCLK/: rccclk.c
    ./USER/TIME/BASICTIM/: basictim.c
    ./USER/TIME/ADVTim/: advancetim.c
    ./USER/TIME/GENTIM/: gentim.c
    ./USER/DMA/: dma.c
    ./USER/USART/: usart.c
    ./USER/WDG/: wdg.c
  group FATFS
    ./USER/FATFS/: fatfsuser.c diskio.c ff.c
    ./USER/FATFS/option/: cc936.c
  group DOC
    ./: readme.txt
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
