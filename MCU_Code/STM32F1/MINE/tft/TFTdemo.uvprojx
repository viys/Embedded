# Keil uVision project TFTdemo.uvprojx, settings and files
target TFT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFTdemo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\USER;.\USER\SYSTICK;.\USER\USART;.\USER\SPI;.\USER\DMA;.\USER\LCD;.\USER\KEY;.\USER\REALYS;.\USER\REMOTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c
    ./USER/SYSTICK/: systick.c
    ./USER/USART/: usart.c
    ./USER/SPI/: spi.c
    ./USER/LCD/: lcd.c lcd_init.c
    ./USER/DMA/: dma.c
    ./USER/KEY/: key.c
    ./USER/REALYS/: relays.c
    ./USER/REMOTE/: remote.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
