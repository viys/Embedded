# Keil uVision project STM32F10.uvprojx, settings and files
target STM32F103_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: .\USER;.\CMSIS\Include;.\USER\ADC;.\USER\NVIC;.\USER\SYSTICK;.\USER\USART;.\USER\GPIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c
    ./USER/NVIC/: nvic.c
    ./USER/SYSTICK/: systick.c
    ./USER/USART/: usart.c
    ./USER/ADC/: adc.c
    ./USER/GPIO/: gpio.c
