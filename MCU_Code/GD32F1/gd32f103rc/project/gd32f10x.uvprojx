# Keil uVision project gd32f10x.uvprojx, settings and files
target Engineering Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD, __FPU_PRESENT
  c include: ..\User;..\CMSIS\Include;..\Library\Include;..\User\LED;..\User\KEY;..\User\USART;..\User\ADC;..\User\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARUP
    ../CMSIS/Startup/: startup_gd32f10x_hd.s
  group CMSIS
    ../CMSIS/: system_gd32f10x.c
  group Firmware
    ../Library/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group USER
    ../User/: gd32f10x_it.c systick.c main.c
    ../User/KEY/: key.c
    ../User/LED/: led.c
    ../User/USART/: usart.c
    ../User/ADC/: adc.c
    ../User/OLED/: oled.c
