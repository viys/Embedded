# Keil uVision project YW201(GD32F103RC).uvprojx, settings and files
target YW201 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YW201(GD32F103RB)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\CMSIS;..\CMSIS\GD\GD32F10x\Include;..\main;..\GD32F10x_standard_peripheral\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ../main/: main.c gd32f10x_it.c gd32f10x_it.h FreeRTOSConfig.h
    ./: 实验说明.txt
  group Startup
    ../CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group CMSIS
    ../CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Periperal
    ../GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group FreeROTS_CORE
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeROTS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_2.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
